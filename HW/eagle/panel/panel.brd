# Repository lsel2014/lsel2014

File README:

LSEL 2014

Build-deps
-libreadline-dev
-xenomai kernel with headers

I2C IDs

- Sun: 0x20
- Sensors: 0x21 - 0x24

Train ID:

- RENFE: 0x2C
- Diesel: 0x34

Roses are gray
Violets are gray
Everything is gray
I'm a dog

                       ,:'/   _..._
                      // ( `""-.._.'
                      \| /    6\___
                      |     6      4
                      |            /
                      \_       .--'
                      (_'---'`)
                      / `'---`()
                    ,'        |
    ,            .'`          |
    )\       _.-'             ;
   / |    .'`   _            /
 /` /   .'       '.        , |
/  /   /           \   ;   | |
|  \  |            |  .|   | |
 \  `"|           /.-' |   | |
  '-..-\       _.;.._  |   |.;-.
        \    <`.._  )) |  .;-. ))
        (__.  `  ))-'  \_    ))'
            `'--"`       `"""`

## EAGLE design HW/eagle/panel/panel.brd

Board: 2 copper layers, 99.6 x 163.1 mm, 229 parts (32 on the bottom side), 188 nets.

Parts:
C1, C2, C11, C12, C13, C26, C38, C42: 0603-CAP
C3, C8, C19: 10u; 1206
C4: 1.5n; 0603-CAP
C5: 4.7u; 0805
C6: 10n; 0603-CAP
C7, C14, C17, C18, C24, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C39: 100n; 0603-CAP
C9: 47u; 1210
C10: 1210
C15: 220n; 0805
C16, C23: SANYO-OSCON_SMD_E7
C20, C21: 1u; 0603-CAP
C22: 220n; C0805
C25: 10u; C0805
C40, C41: 100n; 1206
D1: MBRS340T3; SMC
D2: PMEG6010CEH; SOD123
D3: DO-214AC
D4, D5, D6, D7, D8: BAT54; SOT23
G1, G2: CR2032H
GPIO: PINHD-3X8; 3X08
GPIO_EN: 1X02
I2C, I2C0_A, I2C0_B, I2C1, I2C1_A, I2C1_B, I2C2, I2C_1, I2C_2, I2C_3: JST-PH4
I2C0_EN, I2C1_EN: 1X02
I2C0_PUP, I2C0_PWR, I2C1_PUP, I2C1_PWR: JUMPER-3PTH; 1X03
IC1: 78L12F; SOT89
ICSP2, ICSP3: AVR_SPI_PRG_62X3_LOCK; 2X3_LOCK
IO_LVL: JP2
J1: POWER_JACKPTH_LOCK; POWER_JACK_PTH_LOCK
J2, J11, J12, J13, J14: JST-S4B-PH
J3, J4, J5, J6: JST-XHA-2
JP1, JP16, JP17: 1X03
JP2, JP3, JP6, JP7, JP9, JP10, JP12, JP13, JP18, JP19: JST-4-PTH
JP4, JP5, JP8, JP11, JP14, JP15, JP20: 2X03
LED, LED13, LED26: JST-PH4
LED1, LED2, LED7, LED8, LED9, LED10, LED12: LED-0603
LED6, LED11: LED3MM
LED18, LED19, LED20, LED22, LED23, LED24: LED5MM
LED21, LED25: LED-1206
NRF24: M04X2; 2X4
P1: JST-PH2
PGOOD: CHIP-LED0603
PWM, PWM1, PWM2: JST-PH4
Q1: MOSFET-NCHANNEL2N7002PW; SOT323
R1, R2, R3, R4, R5, R14, R17, R49, R65: 0603-RES
R6: 28.7k; 0603-RES
R7: 50k; 0603-RES
R8: 357k; 0603-RES
R9: 51.1k; 0603-RES
R10, R20, R25, R33, R38, R43: 10k; 0603-RES
R11: 6.04k; 0603-RES
R12: 91k; 0603-RES
R13: 2k; 1206
R15, R55, R56, R57, R60, R61, R62: 100; 1206
R16: 0.25; R2512
R18, R19, R23, R24, R28, R29, R30, R31, R32, R36, R37, R41, R42, R46, R47, R48: 1k; 0603-RES
R21, R26, R34, R39, R44: 100; 0603-RES
R22, R27, R35, R40, R45: 2.2k; 0603-RES
R58, R59, R63, R64: 1k; 1206
RAILAMP: JST-PH4
RST: SKHMPSE010; SKHMPXE010
SPI0, SPI1: JST-PH8
SW1, SW2: JS102011SAQN
T2: WE_EP10_SMD_8PIN
TINY, TINY1, TINY2: Tiny45-20-SMT; SO08-EIAJ
TSOP1, TSOP2, TSOP3, TSOP4, TSOP4836: TSOP4836; TSOP18XX
U1: LT3575IFEPBF; SOP65P640X110-17N
U2: TXB0108PWR; SOP65P640X120-20N
U3, U4: PCA9515ADP; SOP65P490X110-8N
U5: V_REG_LDOSMD; SOT23-5
U6: MCP1826T-5002E/DC; SOT230P700X180-6N
U7: A4950; SOIC8THROUG
U8: SI8420; SO-08
U9: LP2985-5.0; SOT23-5
U10, U11, U12, U13, U14, U15, U16, U18, U19: Tiny45-20-SMT; SO08-EIAJ
U$1: RPI-B-V2SHIELD; RPI-B-V2-SHIELD
U$2, U$4: JUMP3_DESC_LEFT
U$3, U$5: JUMP3_DESC_RIGHT

Connections:
3.3V: C1.1, C2.1, C12.1, C18.2, I2C0_PUP.3, I2C0_PWR.3, I2C1_PUP.3, I2C1_PWR.3, IO_LVL.3, NRF24.2, R1.1, SPI0.1, SPI1.1, U2.2, U3.8, U4.8, U5.5
5V: C11.1, C13.1, C19.2, I2C0_PUP.1, I2C0_PWR.1, I2C1_PUP.1, I2C1_PWR.1, IO_LVL.1, PGOOD.A, U5.1, U5.3, U6.4, U$1.P1_2, U$1.P1_4, U$1.P5_1
+3V3: U$1.P1_1, U$1.P1_17, U$1.P5_2
CE0: NRF24.3, SPI0.7, U$1.P1_24
CE1: SPI1.7, U$1.P1_26
GND: C1.2, C2.2, C9.1, C10.1, C11.2, C12.2, C13.2, C16.-, C17.2, C18.1, C19.1, D3.A, GPIO.17, GPIO.18, GPIO.19, GPIO.20, GPIO.21, GPIO.22, GPIO.23, GPIO.24, GPIO_EN.1, I2C0_A.3, I2C0_B.3, I2C0_EN.1, I2C1_A.3, I2C1_B.3, I2C1_EN.1, NRF24.1, Q1.2, R15.1, RAILAMP.3, RST.1, RST.2, RST.5, SPI0.2, SPI1.2, T2.5, T2.6, U2.11, U3.4, U4.4, U5.2, U6.3, U6.6, U$1.P1_6, U$1.P1_9, U$1.P1_14, U$1.P1_20, U$1.P1_25, U$1.P5_7, U$1.P5_8, U$1.P6_2
GND-ISO: C3.1, C5.1, C6.2, C8.1, J1.GND, J1.GNDBREAK, J3.P$2, J4.P$2, R6.2, R7.2, R9.1, R10.2, R11.2, U1.13, U1.14, U1.17
GNDAMP: C7.2, C14.1, C20.1, C21.1, C22.2, C23.-, C25.2, IC1.2, IC1.2@1, J6.P$2, P1.1, R16.1, U7.P1, U8.5, U9.2
GNDBARRERA: C26.2, I2C.3, I2C_2.3, JP1.3, LED.4, PWM.3, TINY.4
GNDBARRERA1: C38.2, I2C1.3, I2C_1.3, JP16.3, LED13.4, PWM1.3, TINY1.4
GNDBARRERA2: C42.2, I2C2.3, I2C_3.3, JP17.3, LED26.4, PWM2.3, TINY2.4
GNDRX: C27.1, C28.2, JP2.3, JP3.3, JP4.6, R19.1, R22.1, TSOP4836.GND, U10.4
GNDRX1: C31.1, C32.2, JP6.3, JP7.3, JP8.6, R32.1, R35.1, TSOP1.GND, U13.4
GNDRX2: C33.1, C34.2, JP9.3, JP10.3, JP11.6, R37.1, R40.1, TSOP2.GND, U14.4
GNDRX3: C35.1, C36.2, JP12.3, JP13.3, JP14.6, R42.1, R45.1, TSOP3.GND, U15.4
GNDRX4: C29.1, C39.2, JP18.3, JP19.3, JP20.6, R24.1, R27.1, TSOP4.GND, U11.4
GNDSEM2: C40.2, ICSP2.6, J11.P$2, J12.P$3, LED18.K, LED19.K, LED20.K, LED21.C, U18.4
GNDSEM3: C41.2, ICSP3.6, J13.P$2, J14.P$3, LED22.K, LED23.K, LED24.K, LED25.C, U19.4
GNDTX: C30.2, G1.-, JP5.6, R30.1, U12.4
GNDTX1: C37.2, G2.-, JP15.6, R48.1, U16.4
GPIO18: SPI1.5, U$1.P1_15
GPIO22: SPI1.6, U$1.P1_12
GPIO23: NRF24.4, SPI0.5, U$1.P1_18
GPIO24: U2.1, U$1.P1_16
GPIO25+: NRF24.8, SPI0.6, U$1.P1_22
GPIO27: U2.5, U$1.P1_13
GPIO30: U2.8, U$1.P5_5
GPIO30T: GPIO.13, RAILAMP.1, U2.13
GPIO31: U2.9, U$1.P5_6
GPIO31T: GPIO.15, RAILAMP.4, U2.12
LED1: LED.2, TINY.2
LED2: LED.3, TINY.3
LED3: LED13.3, TINY1.3
LED4: LED13.2, TINY1.2
LED5: LED26.3, TINY2.3
LED6: LED26.2, TINY2.2
MISO: NRF24.7, SPI0.8, SPI1.8, U$1.P1_21
MISORX: D4.3, JP4.1, R22.2, U10.6
MISORX1: D5.3, JP8.1, R35.2, U13.6
MISORX2: D6.3, JP11.1, R40.2, U14.6
MISORX3: D7.3, JP14.1, R45.2, U15.6
MISORX4: D8.3, JP20.1, R27.2, U11.6
MISOSEM2: ICSP2.1, R57.2, U18.6
MISOSEM3: ICSP3.1, R62.2, U19.6
MISOTX: JP5.1, LED6.A, U12.6
MISOTX1: JP15.1, LED11.A, U16.6
MOSI: NRF24.6, SPI0.4, SPI1.4, U$1.P1_19
MOSISEM2: ICSP2.4, J11.P$4, J12.P$1, U18.5
MOSISEM3: ICSP3.4, J13.P$4, J14.P$1, U19.5
MOSITX: JP5.4, R29.1, U12.5
MOSITX1: JP15.4, R47.1, U16.5
unnamed: C17.1, GPIO.2, GPIO.4, GPIO.6, GPIO.8, GPIO.10, GPIO.12, GPIO.14, GPIO.16, IO_LVL.2, RAILAMP.2, U2.19
unnamed: U2.3, U$1.P1_10
unnamed: U2.6, U$1.P1_11
unnamed: U2.4, U$1.P1_8
unnamed: U2.7, U$1.P1_7
unnamed: I2C0_A.4, I2C0_B.4, R3.1, U3.7
unnamed: I2C0_A.1, I2C0_B.1, R2.1, U3.6
unnamed: I2C1_A.1, I2C1_B.1, R4.1, U4.6
unnamed: U3.3, U$1.P5_3
unnamed: U3.2, U$1.P5_4
unnamed: U4.3, U$1.P1_3
unnamed: U4.2, U$1.P1_5
unnamed: I2C0_EN.2, U3.5
unnamed: C6.1, U1.7
unnamed: I2C0_PUP.2, R2.2, R3.2
unnamed: I2C1_EN.2, U4.5
unnamed: GPIO_EN.2, R1.2, U2.10
unnamed: C24.2, J2.P$2, U8.4
unnamed: J2.P$1, U8.3
unnamed: I2C0_A.2, I2C0_B.2, I2C0_PWR.2
unnamed: I2C1_A.4, I2C1_B.4, R5.1, U4.7
unnamed: C24.1, J2.P$3, U8.1
unnamed: I2C1_A.2, I2C1_B.2, I2C1_PWR.2
unnamed: I2C1_PUP.2, R4.2, R5.2
unnamed: D1.A, T2.7, T2.8
unnamed: R6.1, U1.12
unnamed: C4.2, U1.9
unnamed: C4.1, R7.1
unnamed: C5.2, U1.5
unnamed: R8.1, R9.2, U1.6
unnamed: R10.1, U1.8
unnamed: R11.1, U1.11
unnamed: R12.1, U1.10
unnamed: C15.2, D2.C, R13.2
unnamed: J2.P$4, U8.2
unnamed: PGOOD.C, Q1.3
unnamed: R14.1, T2.2
unnamed: R14.2, T2.1
unnamed: C9.2, C10.2, C16.+, D1.C, D3.C, R15.2, U6.1, U6.2
unnamed: U7.P3, U8.7
unnamed: U7.P2, U8.6
unnamed: R16.2, U7.P7
unnamed: GPIO.1, U2.20
unnamed: GPIO.3, U2.18
unnamed: GPIO.5, U2.17
unnamed: GPIO.7, U2.16
unnamed: GPIO.9, U2.15
unnamed: GPIO.11, U2.14
unnamed: J5.P$1, U7.P8
unnamed: J5.P$2, U7.P6
unnamed: C25.1, IC1.1, P1.2
unnamed: R17.1, TINY.1
unnamed: LED1.C, R19.2
unnamed: C28.1, R21.2, TSOP4836.VCC
unnamed: LED2.C, R24.2
unnamed: C39.1, R26.2, TSOP4.VCC
unnamed: LED6.K, R29.2
unnamed: LED7.C, R30.2
unnamed: G1.+, SW1.2
unnamed: LED8.C, R32.2
unnamed: C32.1, R34.2, TSOP1.VCC
unnamed: LED9.C, R37.2
unnamed: C34.1, R39.2, TSOP2.VCC
unnamed: LED10.C, R42.2
unnamed: C36.1, R44.2, TSOP3.VCC
unnamed: LED11.K, R47.2
unnamed: LED12.C, R48.2
unnamed: G2.+, SW2.2
unnamed: R49.1, TINY1.1
unnamed: R55.2, U18.3
unnamed: R56.2, U18.2
unnamed: LED18.A, R55.1
unnamed: LED19.A, R56.1
unnamed: LED20.A, R57.1
unnamed: LED21.A, R58.1
unnamed: R60.2, U19.3
unnamed: R61.2, U19.2
unnamed: LED22.A, R60.1
unnamed: LED23.A, R61.1
unnamed: LED24.A, R62.1
unnamed: LED25.A, R63.1
unnamed: R65.1, TINY2.1
PWM: JP1.1, PWM.1, TINY.6
PWM1: JP16.1, PWM1.1, TINY1.6
PWM2: JP17.1, PWM2.1, TINY2.6
RESET: Q1.1, RST.3, RST.4, U6.5, U$1.P6_1
RESETSEM2: ICSP2.5, R59.2, U18.1
RESETSEM3: ICSP3.5, R64.2, U19.1
RESETTX: JP5.5, R28.2, U12.1
RESETTX1: JP15.5, R46.2, U16.1
RST: JP4.5, R18.2, U10.1
RST1: JP8.5, R31.2, U13.1
RST2: JP11.5, R36.2, U14.1
RST3: JP14.5, R41.2, U15.1
RST4: JP20.5, R23.2, U11.1
SCK: NRF24.5, SPI0.3, SPI1.3, U$1.P1_23
SCKSEM2: ICSP2.3, J11.P$1, J12.P$4, U18.7
SCKSEM3: ICSP3.3, J13.P$1, J14.P$4, U19.7
SCKTX: JP5.3, U12.7
SCKTX1: JP15.3, U16.7
SCL: I2C.4, I2C_2.4, TINY.7
SCL1: I2C1.4, I2C_1.4, TINY1.7
SCL2: I2C2.4, I2C_3.4, TINY2.7
SCLRX: JP2.4, JP3.4, JP4.3, U10.7
SCLRX1: JP6.4, JP7.4, JP8.3, U13.7
SCLRX2: JP9.4, JP10.4, JP11.3, U14.7
SCLRX3: JP12.4, JP13.4, JP14.3, U15.7
SCLRX4: JP18.4, JP19.4, JP20.3, U11.7
SDA: I2C.1, I2C_2.1, TINY.5
SDA1: I2C1.1, I2C_1.1, TINY1.5
SDA2: I2C2.1, I2C_3.1, TINY2.5
SDA/MOSI: JP2.1, JP3.1, JP4.4, U10.5
SDA/MOSI1: JP6.1, JP7.1, JP8.4, U13.5
SDA/MOSI2: JP9.1, JP10.1, JP11.4, U14.5
SDA/MOSI3: JP12.1, JP13.1, JP14.4, U15.5
SDA/MOSI4: JP18.1, JP19.1, JP20.4, U11.5
SENSOR_OUT: D4.1, R20.1, TSOP4836.OUT
SENSOR_OUT1: D5.1, R33.1, TSOP1.OUT
SENSOR_OUT2: D6.1, R38.1, TSOP2.OUT
SENSOR_OUT3: D7.1, R43.1, TSOP3.OUT
SENSOR_OUT4: D8.1, R25.1, TSOP4.OUT
SW: D2.A, R12.2, T2.4, U1.3, U1.4
VBAT: C20.2, C22.1, C23.+, IC1.3, J6.P$1, U7.P5, U9.1, U9.3
VCC: C26.1, I2C.2, I2C_2.2, JP1.2, PWM.2, R17.2, TINY.8
VCC1: C38.1, I2C1.2, I2C_1.2, JP16.2, PWM1.2, R49.2, TINY1.8
VCC2: C42.1, I2C2.2, I2C_3.2, JP17.2, PWM2.2, R65.2, TINY2.8
VCCRX: C27.2, JP2.2, JP3.2, JP4.2, LED1.A, R18.1, R20.2, R21.1, U10.8
VCCRX1: C31.2, JP6.2, JP7.2, JP8.2, LED8.A, R31.1, R33.2, R34.1, U13.8
VCCRX2: C33.2, JP9.2, JP10.2, JP11.2, LED9.A, R36.1, R38.2, R39.1, U14.8
VCCRX3: C35.2, JP12.2, JP13.2, JP14.2, LED10.A, R41.1, R43.2, R44.1, U15.8
VCCRX4: C29.2, JP18.2, JP19.2, JP20.2, LED2.A, R23.1, R25.2, R26.1, U11.8
VCCSEM2: C40.1, ICSP2.2, J11.P$3, J12.P$2, R58.2, R59.1, U18.8
VCCSEM3: C41.1, ICSP3.2, J13.P$3, J14.P$2, R63.2, R64.1, U19.8
VCCTX: C30.1, JP5.2, LED7.A, R28.1, SW1.3, U12.8
VCCTX1: C37.1, JP15.2, LED12.A, R46.1, SW2.3, U16.8
VDD2: C7.1, C14.2, C21.2, U7.P4, U8.8, U9.5
VIN: C3.2, C8.2, C15.1, J1.PWR, J3.P$1, J4.P$1, R8.2, R13.1, T2.3, U1.2

## EAGLE design HW/eagle/panel/tx_train.brd

Parts:
C1: 100n; 0603-CAP
G1: CR2032H
JP1: PINHD-2X3; 2X03
LED1: LED3MM
LED2: LED0603; LED-0603
R1, R2, R3: 1k; 0603-RES
SW1: JS102011SAQN
U1: Tiny45-20-SMT; SO08-EIAJ

Connections:
GND: C1.2, G1.-, JP1.6, R3.1, U1.4 (GND)
MISO: JP1.1, LED1.A, U1.6 (PB1(MISO))
MOSI: JP1.4, R2.1, U1.5 (PB0(MOSI))
unnamed: LED1.K (C), R2.2
unnamed: G1.+, SW1.2
unnamed: LED2.C, R3.2
RESET: JP1.5, R1.2, U1.1 (PB5(NRES))
SCK: JP1.3, U1.7 (PB2(SCK/ADC1))
VCC: C1.1, JP1.2, LED2.A, R1.1, SW1.3, U1.8 (VCC)

Board: 2 copper layers, 32.0 x 20.0 mm, 10 parts (1 on the bottom side), 9 nets.

## EAGLE design HW/eagle/LSEL-Sensors/rx_sensor.brd

Board: 4 copper layers, 22.0 x 20.0 mm, 14 parts (6 on the bottom side), 9 nets.

Parts:
C1, C2: 0603-CAP
D1: BAT54; SOT23
JP1, JP2: JST-4-PTH
JP3: 2X03
LED1: LED-0603
R1, R2, R3, R4, R5: 0603-RES
U1: Tiny45-20-SMT; SO08-EIAJ
U$1: TSOP4836; TSOP18XX

Connections:
GND: C1.1, C2.2, JP1.3, JP2.3, JP3.6, R2.1, R5.1, U1.4, U$1.GND
MISO: D1.1, JP3.1, R3.1, U$1.OUT
unnamed: LED1.C, R2.2
unnamed: C2.1, R4.2, U$1.VCC
unnamed: D1.3, R5.2, U1.6
RST: JP3.5, R1.2, U1.1
SCL: JP1.4, JP2.4, JP3.3, U1.7
SDA/MOSI: JP1.1, JP2.1, JP3.4, U1.5
VCC: C1.2, JP1.2, JP2.2, JP3.2, LED1.A, R1.1, R3.2, R4.1, U1.8

## EAGLE design HW/eagle/LSEL-semaforo/semaforo.brd

Parts:
C1: 100n; 1206
ICSP: AVR_SPI_PRG_62X3_LOCK; 2X3_LOCK
J1, J2: JST-S4B-PH
LED1, LED2, LED3: LED5MM
LED4: LED1206; LED-1206
R1, R2, R3: 100; 1206
R4, R5: 1k; 1206
U1: Tiny45-20-SMT; SO08-EIAJ

Connections:
GND: C1.2, ICSP.6, J1.P$2, J2.P$3, LED1.K (C), LED2.K (C), LED3.K (C), LED4.C, U1.4 (GND)
MISO: ICSP.1, R3.2, U1.6 (PB1(MISO))
MOSI: ICSP.4, J1.P$4, J2.P$1, U1.5 (PB0(MOSI))
unnamed: R1.2, U1.3 (PB4(ADC2))
unnamed: R2.2, U1.2 (PB3(ADC3))
unnamed: LED4.A, R4.1
unnamed: LED1.A, R1.1
unnamed: LED2.A, R2.1
unnamed: LED3.A, R3.1
RESET: ICSP.5, R5.2, U1.1 (PB5(NRES))
SCK: ICSP.3, J1.P$1, J2.P$4, U1.7 (PB2(SCK/ADC1))
VCC: C1.1, ICSP.2, J1.P$3, J2.P$2, R4.2, R5.1, U1.8 (VCC)

Board: 2 copper layers, 33.0 x 30.0 mm, 14 parts (0 on the bottom side), 12 nets.

## EAGLE design Modules/LED driver/Hardware/driverLED.brd

Parts:
BSS306N: BSS306N; SOT23
C1, C2: 1u; C0603
C3, C4: 100n; C0603
C10: 47u; C1812
CON1: PINHD-1X2; 1X02
JP1: JUMPER-2PTH; 1X02
JP2: PINHD-1X6; 1X06
L1: NR10050T470M
OK1: H11L1MS; DIL6-SMD
PAD1, PAD2: WIREPADSMD2,54-5,08; SMD2,54-5,08
R1, R2, R3: .33R; R1206
R6, R11: R-EU_R0603; R0603
R7, R8: 4.7k; R0603
R9: 1k; R0603
R10: 100R; R0603
SD1: PMEG3020EH,115; SOD123F
SJ1: JUMPER_SJ
U1: ILD4001; SC74
U$1: PIC12F1822; 8-SOIC
U$2: SMARTPRJ_POWERSUPPLY_DC21MMX; SMARTPRJ_POWERSUPPLY_DC-21MM
VR1: MIC5205; SOT-23-5

Connections:
3V3: C1.2, C3.2, JP1.2, SJ1.1, U$1.1 (VDD), VR1.5 (OUT)
5V: C2.2, JP2.2, VR1.1 (IN), VR1.3 (EN)
CCP1: C4.2, R9.2, U$1.2 (RA5)
GND: BSS306N.2, C10.2, CON1.2, OK1.5 (GND), R6.1, U1.2 (GND), U1.5 (GND), U$2.1, U$2.3
GND1: C1.1, C2.1, C3.1, JP2.3, OK1.2 (C), U$1.3 (RA4), U$1.8 (VSS), VR1.2 (GND)
MCLR: JP2.1, U$1.4 (!MCLR/VPP/RA3)
unnamed: OK1.1 (A), R10.2
unnamed: L1.2, PAD1.1
unnamed: BSS306N.1, R6.2, U1.4 (VDRIVE)
unnamed: JP1.1, R7.2, R8.2, SJ1.2
unnamed: CON1.1, OK1.4 (OUT), R11.1, U1.3 (EN/PWM)
unnamed: PAD2.1, R1.1, R2.1, R3.1, U1.6 (ISENSE)
unnamed: JP2.6, R8.1, U$1.5 (RA2)
unnamed: C4.1, R9.1, R10.1
RA0: JP2.4, U$1.7 (RA0/ICSPDAT)
RA1: JP2.5, R7.1, U$1.6 (RA1/ICSPCLK)
TP3: BSS306N.3, L1.1, SD1.2
VS: C10.1, OK1.6 (VCC), R1.2, R2.2, R3.2, R11.2, SD1.1, U1.1 (VS), U$2.2

Board: 2 copper layers, 57.0 x 24.0 mm, 28 parts (0 on the bottom side), 18 nets.

## EAGLE design HW/eagle/panel/amplivias.brd

Board: 2 copper layers, 49.1 x 37.4 mm, 17 parts (0 on the bottom side), 13 nets.

Parts:
C1, C2, C3: 100n; 0603-CAP
C4, C5: 1u; 0603-CAP
C6: 220n; C0805
C7: SANYO-OSCON_SMD_E7
C8: 10u; C0805
IC1: 78L12F; SOT89
J1: JST-S4B-PH
J2, J4: JST-XHA-2
P1: JST-PH2
R1: 0.25; R2512
U1: SI8420; SO-08
U2: LP2985-5.0; SOT23-5
U3: A4950; SOIC8THROUG

Connections:
GND: C2.2, C3.1, C4.1, C5.1, C6.2, C7.-, C8.2, IC1.2, IC1.2@1, J2.P$2, P1.1, R1.1, U1.5, U2.2, U3.P1
unnamed: C1.2, J1.P$2, U1.4
unnamed: J1.P$1, U1.3
unnamed: C1.1, J1.P$3, U1.1
unnamed: J1.P$4, U1.2
unnamed: R1.2, U3.P7
unnamed: U1.7, U3.P3
unnamed: U1.6, U3.P2
unnamed: C8.1, IC1.1, P1.2
unnamed: J4.P$1, U3.P8
unnamed: J4.P$2, U3.P6
VBAT: C4.2, C6.1, C7.+, IC1.3, J2.P$1, U2.1, U2.3, U3.P5
VDD2: C2.1, C3.2, C5.2, U1.8, U2.5, U3.P4

## Code that names these connections

File Modules/PICsun.X/PICsun_main.c:

/* 
 * File:   newmain.c
 * Author: Javier Gonzalez Recio
 *
 */

#include <stdio.h>
#include <stdlib.h>
#include <xc.h> // include standard header file
#include "PICsun_constants.h"

#define I2C_ADDR        0x20
#define _XTAL_FREQ      16000000    // 16MHz

// set Config bits
#pragma config FOSC=INTOSC, PLLEN=OFF, WDTE=OFF, MCLRE=OFF
#pragma config CLKOUTEN=OFF, IESO=OFF, FCMEN=OFF, CP=OFF, CPD=OFF, BOREN=OFF
#pragma config WRT=OFF, STVREN=ON, BORV=LO, LVP=OFF

#define __delay_ms(x) _delay((unsigned long)((x)*(_XTAL_FREQ/16000.0)))

volatile unsigned int     sunrise_hms[3] , sunset_hms[3];
volatile unsigned int     real_time;
volatile unsigned int     light_segments[LIGHT_SEGMENTS_N+1];
volatile unsigned int     present_segment;

void i2c_rcv(void) {

    int rcvd_bytes;
    int trash;
    
    trash = SSPBUF;     //Clear the buffer by reading it

    /* Reciving chars
    while (rcvd_bytes < 8) {
        if (SSPSTATbits.BF == 1 && SSPSTATbits.D_nA == 1) {
            if(rcvd_bytes == 0 || rcvd_bytes == 1) {
                sunrise_h[rcvd_bytes] = SSPBUF;
            } else if (rcvd_bytes == 3 || rcvd_bytes == 4 ) {
                sunrise_m[rcvd_bytes-3] = SSPBUF;
            } else if (rcvd_bytes == 6 || rcvd_bytes == 7 ) {
                sunrise_s[rcvd_bytes-6] = SSPBUF;
            } else {
                SSPSTATbits.BF = 0;     //Clear the buffer full flag
            }
            SSPSTATbits.D_nA == 0;
            rcvd_bytes++;
        }
    }

    rcvd_bytes = 0;
    while (rcvd_bytes < 8) {
        if (SSPSTATbits.BF == 1 && SSPSTATbits.D_nA == 1) {
            if(rcvd_bytes == 0 || rcvd_bytes == 1) {
                sunset_h[rcvd_bytes] = SSPBUF;
            } else if (rcvd_bytes == 3 || rcvd_bytes == 4 ) {
                sunset_m[rcvd_bytes-3] = SSPBUF;
            } else if (rcvd_bytes == 6 || rcvd_bytes == 7 ) {
                sunset_s[rcvd_bytes-6] = SSPBUF;
            } else {
                SSPSTATbits.BF = 0;     //Clear the buffer full flag
            }
            SSPSTATbits.D_nA == 0;
            rcvd_bytes++;
        }
    }
    */

    //int
    for (rcvd_bytes = 0; rcvd_bytes <= 2; rcvd_bytes++) {
        if (SSPSTATbits.BF == 1 && SSPSTATbits.D_nA == 1) {
            sunrise_hms[rcvd_bytes] = SSPBUF;
            SSPSTATbits.BF = 0;         //Clear the buffer full flag
            SSPSTATbits.D_nA = 0;       //Clear the data/address flag, so we can recive another byte
            rcvd_bytes++;
        }
    }

    for (rcvd_bytes = 0; rcvd_bytes <= 2; rcvd_bytes++) {
        if (SSPSTATbits.BF == 1 && SSPSTATbits.D_nA == 1) {
            sunset_hms[rcvd_bytes] = SSPBUF;
            SSPSTATbits.BF = 0;         //Clear the buffer full flag
            SSPSTATbits.D_nA = 0;       //Clear the data/address flag, so we can recive another byte
            rcvd_bytes++;
        }
    }

    PIR1bits.SSP1IF = 0; //clear the interruption flag

}

void calc_times(void) {
    /* chars
    int sunrise_seconds = atoi(&sunrise_h[0]) * 3600 + atoi(&sunrise_m[0]) * 60 + atoi(&sunrise_s[0]);
    int sunset_seconds = atoi(&sunset_h[0]) * 3600 + atoi(&sunset_m[0]) * 60 + atoi(&sunset_s[0]);
    */

    //ints
    int sunrise_seconds = sunrise_hms[0] * 3600 + sunrise_hms[1] * 60 + sunrise_hms[2];
    int sunset_seconds = sunset_hms[0] * 3600 + sunset_hms[1] * 60 + sunset_hms[2];
    unsigned int light_time = sunset_seconds - sunrise_seconds;
    unsigned int segment_duration = light_time/LIGHT_SEGMENTS_N;
    int i = 0;

    for (i = 0; i <= LIGHT_SEGMENTS_N; i++) {
        light_segments[i] = sunrise_seconds + i*segment_duration;
    }

    real_time = 0;          //reset the simulation
    present_segment = 0;

}

void ready_pwm(int segment) {
    if (segment == 0) {
        //1023 -> 0b1111111111
        CCPR1L = 0b11111111;
        CCP1CONbits.DC1B = 0b11;
    } else if (segment == 1) {
        //976  -> 0b1111010000
        CCPR1L = 0b11110100;
        CCP1CONbits.DC1B = 0b00;
    } else if (segment == 2) {
        //924  -> 0b1110011100
        CCPR1L = 0b11100111;
        CCP1CONbits.DC1B = 0b00;
    } else if (segment == 3) {
        //864  -> 0b1101100000
        CCPR1L = 0b11011000;
        CCP1CONbits.DC1B = 0b00;
    } else if (segment == 4) {
        //796  -> 0b1100011100
        CCPR1L = 0b11000111;
        CCP1CONbits.DC1B = 0b00;
    } else if (segment == 5) {
        //715  -> 0b1011001011
        CCPR1L = 0b10110010;
        CCP1CONbits.DC1B = 0b11;
    } else if (segment == 6) {
        //616  -> 0b1001101000
        CCPR1L = 0b10011010;
        CCP1CONbits.DC1B = 0b00;
    } else if (segment == 7) {
        //488  -> 0b0111101000
        CCPR1L = 0b01111010;
        CCP1CONbits.DC1B = 0b00;
    } else if (segment == 8) {
        //307  -> 0b0100110011
        CCPR1L = 0b11111111;
        CCP1CONbits.DC1B = 0b11;
    } else if (segment == 9) {
        //42   -> 0b0000101010
        CCPR1L = 0b00001010;
        CCP1CONbits.DC1B = 0b10;
    } else if (segment == 10) {
        //0    -> 0b0000000000
        CCPR1L = 0b00000000;
        CCP1CONbits.DC1B = 0b00;
    }
}

void check_segment(int check_time){
    int i;

    if (check_time < light_segments[0] || check_time > light_segments[LIGHT_SEGMENTS_N]) {
        present_segment = 0;
    } else {
        for (i = 0; i < 10; i++) {
            if (check_time > light_segments[i] && check_time < light_segments[i+1]) {
                present_segment = i+1;
                break;
            }
        }
        for (i = 10; i < LIGHT_SEGMENTS_N; i++) {
            if (check_time > light_segments[i] && check_time < light_segments[i+1]) {
                present_segment = 19-i;
                break;
            }
        }
    }
}

void simulate(void) {
    int simulation_time = real_time * SEC_SIM;

    check_segment(simulation_time);
    ready_pwm(present_segment);

    PIR1bits.TMR2IF = 0;    //Clear Timer2 interrupt flag
    T2CONbits.TMR2ON = 1;   //Enable Timer2
    TRISAbits.TRISA5 = 0;   //Enable output

    __delay_ms(5);

    TRISAbits.TRISA5 = 1;   //Disable output

}

void __init(void) {

    // OSCCON: OSCILLATOR CONTROL REGISTER
    OSCCONbits.SPLLEN=0;    //PLL disabled
    OSCCONbits.IRCF=0x0F;   //OSC frequency=16Mhz
    OSCCONbits.SCS=0x02;    //internal oscillator block

    // Set up I/O pins
    // PORT A Assignments
    TRISAbits.TRISA0 = 0;	// RA0 = nc
    TRISAbits.TRISA1 = 1;	// RA1 = SCL
    TRISAbits.TRISA2 = 1;	// RA2 = SDA
    TRISAbits.TRISA3 = 0;	// RA3 = nc (MCLR)
    TRISAbits.TRISA4 = 0;	// RA4 = nc
    TRISAbits.TRISA5 = 1;	// RA5 = CCP1

    // ANSELA: PORTA ANALOG SELECT REGISTER
    ANSELA=0x00;		// all pins are digital I/O
    
    //APFCON: ALTERNATE PIN FUNCTION CONTROL REGISTER
    APFCONbits.CCP1SEL = 1;

    // OPTION_REG: OPTION REGISTER
    OPTION_REG = 0b00000000;

    // WPUA: WEAK PULL-UP PORTA REGISTER
    WPUA = 0b00000000;

    // LATA: PORTA DATA LATCH REGISTER
    LATA = 0b00000000;

    SSP1CON1 = 0b00110110;      // SSP1EN = 1, CKP = 1, SSP1M = Slave mode 7bit
    SSP1CON2bits.SEN = 1;       // Clock stretching is enabled for both slave transmit and slave receive (stretch enabled)
    SSP1ADD = I2C_ADDR << 1;    // bits 7 to 1

    //Timer 2 for PWM
    PR2 = 0xFF;
    CCP1CONbits.CCP1M = 0b1100; //1100 = PWM mode: P1A, P1C active-high; P1B, P1D active-high
    T2CONbits.T2CKPS = 0b11;    //Prescaler = 64

    PIR1bits.SSP1IF = 0;         // Clear MSSP interrupt request flag
    PIE1bits.SSP1IE = 1;         // Enable MSSP interrupt enable bit

    INTCONbits.GIE  = 1;       // GIE: Global Interrupt Enable bit
    INTCONbits.PEIE = 1;       // PEIE: Peripheral Interrupt Enable bit

    __delay_ms(100);
}

int main() {

    __init();

    //default sunrise and sunset
    sunrise_hms[0] = DEFAULT_SUNRISE_H;
    sunrise_hms[1] = DEFAULT_SUNRISE_M;
    sunrise_hms[2] = DEFAULT_SUNRISE_S;
    sunset_hms[0] = DEFAULT_SUNSET_H;
    sunset_hms[1] = DEFAULT_SUNSET_M;
    sunset_hms[2] = DEFAULT_SUNSET_S;
    calc_times();

    while(1) {
        if((PIR1bits.SSP1IF == 1) && (SSPSTATbits.BF == 1) && (SSPSTATbits.D_nA == 0)) {
            i2c_rcv();      //receive the sunrise and sunset data
            calc_times();
        } else {
            simulate();
            //__delay_ms(995);
            if(++real_time == DAY_SIM){
                real_time = 0;
            }
        }
    }

    return (EXIT_SUCCESS);
}

File Modules/sectorsemaphore/main_2.c:

/************************************************************************
 *                                                                      
 * LSEL2014 sector semaphore module
 *
 * @date 26/05/2014 21:16:49
 * @author Javier Gonzalez
 *
 *                             AT tiny 45
 *                 +--------------------------------+
 * Reset		   | 1 pb5 reset              VCC 8 |
 * Green LED	   | 2 pb3                SCL pb2 7 | SCL
 * Red LED		   | 3 pb4 	                  pb1 6 | Yellow LED
 *                 | 4 GND                SDA pb0 5 | SDA
 *                 +--------------------------------+
 ************************************************************************/ 

#include <avr/io.h>
#include <avr/interrupt.h>
#include <util/delay.h>
#include "usiTwiSlave.h" 

#define I2C_SLAVE_ADDR 0x33
#define PIN_G PB3
#define PIN_R PB4
#define PIN_Y PB1

// write digital "high" to pin <pn> on port <prt>
#define DIGIWRITE_H(prt, pn) prt |= (1<<pn)

// write digital "low" to pin <pn> on port <prt>
#define DIGIWRITE_L(prt, pn) prt &= ~(1<<pn)

volatile uint8_t data=0;

uint8_t i2cReadFromRegister(uint8_t reg)
{
	return 0xff;
}

void i2cWriteToRegister(uint8_t reg, uint8_t value)
{

	data=value;
		
}

void setup(void)
{	
	usiTwiSlaveInit(I2C_SLAVE_ADDR, i2cReadFromRegister, i2cWriteToRegister);		//Init I2C Slave mode
	
	sei();
	
	DDRB |= (1<<PIN_G);
	DDRB |= (1<<PIN_Y);
	DDRB |= (1<<PIN_R);						//Pins 2, 3 and 6 (pb1, 2 and 4) as outputs
	
	
	DIGIWRITE_L(PORTB,PIN_G);
	DIGIWRITE_L(PORTB,PIN_Y);
	DIGIWRITE_L(PORTB,PIN_R);
	
}

int main(void)
{
	setup();
	while (1){
		switch (data){
				case 1:	//Green
						DIGIWRITE_H(PORTB,PIN_G);
						DIGIWRITE_L(PORTB,PIN_Y);
						DIGIWRITE_L(PORTB,PIN_R);
						
				case 2://Yellow
						DIGIWRITE_L(PORTB,PIN_G);
						DIGIWRITE_H(PORTB,PIN_Y);
						DIGIWRITE_L(PORTB,PIN_R);
						
				case 3:	//Red
						DIGIWRITE_L(PORTB,PIN_G);
						DIGIWRITE_L(PORTB,PIN_Y);
						DIGIWRITE_H(PORTB,PIN_R);
				
				case 4:
						DIGIWRITE_H(PORTB,PIN_G);
						DIGIWRITE_L(PORTB,PIN_Y);
						DIGIWRITE_H(PORTB,PIN_R);		
			 	default:						//Error
						DIGIWRITE_H(PORTB,PIN_G);
						DIGIWRITE_H(PORTB,PIN_Y);
						DIGIWRITE_H(PORTB,PIN_R);
						
			}
		
	};
	return 0; // Never reached
    
}

File Modules/Changer/main.old.c:

#include <avr/io.h>
#include <util/delay.h>
//#include "usiTwiSlave.h"
#include <avr/interrupt.h>

// Define pins
#define PIN_LED1 PB3
#define PIN_LED2 PB4
#define PIN_PWM PB1

// Define I2C address
#define I2C_ADDRESS 0x57

// Define I2C commands for opening and closing the barrier
#define OPEN_COMMAND 0x30
#define CLOSE_COMMAND 0x31
#define LIGHTS_ON 0x32

// Define states for OCR0B
#define SET_90_DEG 0x0E  //Estos valores hay que calcularlos
#define SET_0_DEG 0x07

// Define the cpu frequency
#define F_CPU 8000000

// write digital "high" to pin <pn> on port <prt>
#define DIGIWRITE_H(prt, pn) prt |= (1<<pn)

// write digital "low" to pin <pn> on port <prt>
#define DIGIWRITE_L(prt, pn) prt &= ~(1<<pn)

int semState = 0;
int ledState = 0;             // ledState used to set the LED
long previousMillis = 0;        // will store last time LED was updated
long interval = 500;

// Define long delay function
void long_delay_ms(uint16_t ms) {
    for(ms /= 10; ms>0; ms--) _delay_ms(10);
}

// method for turning the blinking lights on
void lights_on(void){
	//blinking leds on
	GTCCR = 1<<PWM1B;
}

// method for closing the barrier
void close_barrier(void){
	//set barrier to closed position
	OCR0B = SET_0_DEG;
}

// method for opening the barrier and turning off the blinking lights
void open_barrier(void){
	//blinking leds off
	GTCCR = 0<<PWM1B;
	//set barrier to closed position
	OCR0B = SET_90_DEG;
}

void _init(){
    // Configure the direction register of port B
    // 1 << PIN_LED1 Sets PIN_LED1 as an output
    // 1 << PIN_LED2 Sets PIN_LED2 as an output
    // 1 << PIN_PWM Sets PIN_PWM as an output
    DDRB |= (1 << PIN_LED1) | (1 << PIN_LED2) | (1 << PIN_PWM);

    /*
    Control Register A for Timer/Counter-0
    0<<COM0A0: prevents Timer0 from using pin OC0A
    2<<COM0B0: for non-inverted PWM
    3<<WGM00: enables Fast PWM mode (when combined with WGM02 from TCCR0B below)
    */
    TCCR0A = 0<<COM0A0 | 2<<COM0B0 | 3<<WGM00;
    
    /*
    Control Register B for Timer/Counter-0
    1<<WGM02: enables Fast PWM mode (when combined with WGM00 and WGM01 from TCCR0A above)
    5<<CS00: in order to use prescaler N = 1024
    */
    TCCR0B = 1<<WGM02 | 5<<CS00;

    /*
    Output Compare Registers
	With WGM02 set to 1 (WGM0 = 7) the register OCR0A will set TOP of the count and the
	register ACR0B will be the value compared to the count (TCNT0)
    */
    OCR0A = 0x9C; 
    OCR0B = SET_90_DEG;

    // Set the I2C slave address of the controller
    //usiTwiSlaveInit(I2C_ADDRESS);

    // enable interrupts
    //sei();
}

void loop() {
  unsigned long currentMillis = millis();
 
  if(currentMillis - previousMillis > interval) {
    // save the last time you blinked the LED 
    previousMillis = currentMillis;   

    if(semState ==1) {
      if (ledState == 0) {
        ledState = 1;
        digitalWrite(PIN_LED1, 1);
        digitalWrite(PIN_LED1, 0);
      } else {
        ledState = 0;
        digitalWrite(PIN_LED1, 0);
        digitalWrite(PIN_LED1, 1);
      }
    }
  }
}

int main(void) {
    uint8_t command; 
    _init();
//    while(1) {
//  	// Wait for a command then proceed with the corresponding function
//    	if (usiTwiDataInReceiveBuffer()) {
//		command = usiTwiReceiveByte();
//           	if (command == CLOSE_COMMAND) {
//		  close_barrier();
//           	} else if (command == OPEN_COMMAND) {
//		  open_barrier();
//		} else if (command == LIGHTS_ON) {
//		  lights_on();
//		}
//        }
//    }
    while(1){
       long_delay_ms(2000);
       open_barrier();
       long_delay_ms(2000);
       close_barrier();
    }
}

## Commit log (part)

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2014-04-30 trying to get anti working
2014-04-30 Added bad wait command
2014-04-30 Implemented wait cmd
2014-04-30 Bugfixes
2014-04-30 Trying to fix check-est
2014-04-30 working version of anticollision
2014-04-30 better working anticollision
2014-04-30 Fixed screen display
2014-04-30 Ready-ish for next meeting
2014-05-02 Fixed check_est command
2014-05-02 Bugfix
2014-05-02 Moved time manipulation stuff to its own c file
2014-05-02 check_est bugfix
2014-05-03 Added preliminar automatic tests for arrival time estimator
2014-05-04 Duplicated crash tests for comparison
2014-05-04 Added moooooore documentation and comments
2014-05-07 Screen update
2014-05-07 Fixed Segfault
2014-05-07 cleaning...
2014-05-07 Recovered test files
2014-05-08 simplificando
2014-05-08 plugins
2014-05-12 Added eagle workdir with shield and libraries. Needs sparkfun libraries.
2014-05-12 Added eagle folder. See previous commit
2014-05-12 Routed power supply
2014-05-12 Tweaked a few things
2014-05-12 Work in progress. Added some jst connectors library.
2014-05-13 Routing in progress. Added 8 vias JST PH.
2014-05-13 Routed GPIO translator
2014-05-13 Merged progress in different areas
2014-05-14 More routing
2014-05-14 Added IR sensors
2014-05-14 Routed 3.3V regulator
2014-05-15 Ruteado. Cambiado conectores no JST PH por los correspondientes. Añadido conector para módulo nRF24L01 asociado a SPI0
2014-05-15 Ground partially routed, some cleanup, most designators placed
2014-05-15 Added extra connectors for I2C
2014-05-15 Fixed nRF24L01 connector with board mounting hole. Routing. Removed conflicting ground vias.
2014-05-15 Finished routing
2014-05-16 added semaforo
2014-05-16 Added LL4148 SMD library
2014-05-18 pcb semaforo acabada
2014-05-19 Add logger observer
2014-05-19 new logger
2014-05-19 Added barrier+lights
2014-05-19 fixes
2014-05-19 Fixed I2C connectors on sensor boards
2014-05-19 update
    Removed folder structure and updated crossingGate and trafficLigth by
    adding tracker-like controler.
2014-05-19 Fixed I2C connectors, fixed some gpio buffered connector problems.
2014-05-19 fixed some isues
2014-05-19 Finished IR TX and RX boards
2014-05-19 Minor tweaks
2014-05-20 Added rail amplifier
2014-05-20 IR sensors tower STL -> Ready to print
2014-05-20 Panelized boards for fabrication
2014-05-20 latest panel
2014-05-21 Added BOM
2014-05-25 added first version of sectorsemaphore
2014-05-26 utils from josem
2014-05-26 Semaphore firmware
2014-05-27 Update train.c
    Copy from josem
2014-05-27 Update Makefile
2014-05-27 New ir_tower version 1.1
2014-05-27 Tower v1.1 stl ready to print
    STL sizes exported correctly
2014-05-29 upload from pi
2014-06-04 Added ultimate tower design
    Changed hole dimensions to allow JST-PH connectors in.
2014-06-05 i2c functioning
2014-06-05 firmware semaforo
2014-06-05 Added trainID new firmwares
2014-06-05 semafor
2014-06-05 mas pruebas con semaforo
2014-06-05 Added sensors firmware using new I2C lib
2014-06-05 Corrected a fail
2014-06-11 IR sensors working
2014-06-13 New ir_tower locking system
    Addede ir_tower_v1.3 with new locking system
2014-06-17 final version semaphore firm
2014-06-17 Sector semaphore working
2014-06-17 Barrier added
    Code for the Barrier and its lights added.
    I2C address 0x50
    Comands:
    -open barrier and lights off: 0x30
    -close barrier 0x31
    - lights on 0x32
2014-06-18 from raspi
2014-06-18 Semaphore update
2014-06-18 Added barrier and semaphore
2014-06-18 Light update
2014-06-18 Added Change module.
2014-06-18 lo qde la raspi
2014-06-20 Added latest versions
2014-06-20 almost there
2014-06-20 final-ish
2014-06-23 Added GUI
2014-06-24 almost final

Notices in the files:
parts and their libraries:
SparkFun-DigitalIC: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
raspberry: This library stands under the CERN Open Hardware Licence.
SparkFun: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
